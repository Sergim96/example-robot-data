Commit message: remode gripper joint

File: robots/b1_description/urdf/b1-z1.urdf (robot description, URDF)
Before this commit: robot b1_description, 40 links, 39 joints
Joints:
- joint jointGripper: type revolute -> fixed
